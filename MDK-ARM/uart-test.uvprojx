# Keil uVision project uart-test.uvprojx, settings and files
target uart-test (6140000::V6.14::ARMCLANG)
  device: STM32G431K6Ux STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart-test +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=1
  c define: STM32G431xx,ARM_MATH_LOOPUNROLL
  c include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;.\usr;.\Core\Inc;.\usr\lcd;D:\APP\Keil_v5\ARM\Pack\ARM\CMSIS\5.7.0\CMSIS\DSP\Include;.\usr\STM32_USB_Device_Library\USB_Device\App;.\usr\STM32_USB_Device_Library\USB_Device\Target;.\usr\STM32_USB_Device_Library\Class\CDC\Inc;.\usr\STM32_USB_Device_Library\Core\Inc;..\STM32G4xx_HAL_Driver\Inc;.\usr\STM32_USB_Device_Library\USB_Device\Target;.\usr\STM32_USB_Device_Library;.\usr\STM32_USB_Device_Library\USB_Device;.\usr\sdmmc;.\usr\malloc;.\usr\spi_flash;.\usr\fatfs\source;.\usr\fatfs\exfuns;.\usr\STM32_USB_Device_Library\Class\MSC\Inc;.\usr\STM32_USB_Device_Library\Class\Mult
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ./Core/Src/: main.c
  group Drivers/CMSIS
    ./Core/Src/: system_stm32g4xx.c
  group usr
    ./usr/: sys.c usart.c delay.c spi.c timer.c adc.c dma.c osc.c gpio.c dac.c opamp.c usb_top.c
    ./usr/lcd/: st77xx_lcd_init.c lcd.c
    ./usr/sdmmc/: sdmmc.c usr_sd_app.c
    ./usr/malloc/: malloc.c
    ./usr/spi_flash/: w25qxx.c
  group USB_APP
    ./usr/STM32_USB_Device_Library/USB_Device/Target/: usbd_conf.c
    ./usr/STM32_USB_Device_Library/USB_Device/App/: usbd_cdc_if.c usbd_desc.c usbd_storage_if.c
  group USB_LIB
    ./usr/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./usr/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./usr/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ./usr/STM32_USB_Device_Library/Class/Mult/: usbd_mult.c
  group HAL_DRIVER
    ../STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_usb.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c
  group fatfs
    ./usr/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c fatfs_app.c
    ./usr/fatfs/exfuns/: exfuns.c fattester.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
